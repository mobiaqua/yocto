require rootfs-devel.bb

INSTALL_PKGS += "scummvm libsdl2-dbg"
DEPENDS += ""
RDEPENDS += ""
RRECOMMENDS += ""

IMAGE_BASENAME = "rootfs-devel-scummvm"
