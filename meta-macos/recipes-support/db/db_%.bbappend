EXTRA_OECONF:append:class-native = " --disable-atomicsupport --enable-shared=no"
EXTRA_OECONF:append:class-nativesdk = " --disable-atomicsupport --enable-shared=no"
