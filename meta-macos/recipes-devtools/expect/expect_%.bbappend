
CACHED_CONFIGUREVARS = "tcl_cv_sys_version=Linux"
CACHED_CONFIGUREVARS:darwin:class-native = "tcl_cv_sys_version=Darwin"
