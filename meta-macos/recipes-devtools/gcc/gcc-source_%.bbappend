SRC_URI:remove = "file://0017-handle-sysroot-support-for-nativesdk-gcc.patch"
