BUILD_CFLAGS:class-native += "-Wno-int-conversion"
