EXTRA_OECONF:append:class-native = " --enable-shared=no --disable-bzlib"
EXTRA_OECONF:append:class-nativesdk = " --enable-shared=no --disable-bzlib"
