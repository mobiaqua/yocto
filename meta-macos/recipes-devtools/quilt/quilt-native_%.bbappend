EXTRA_OECONF:append:class-native = " --without-getopt"
EXTRA_OECONF:append:class-nativesdk = " --without-getopt"
