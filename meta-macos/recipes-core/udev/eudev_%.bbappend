PACKAGECONFIG:remove = "hwdb"
PACKAGE_WRITE_DEPS:remove = "qemu-native"
