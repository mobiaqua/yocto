EXTRA_OECMAKE:append:class-native = " -DBUILD_SHARED_LIBS=OFF"
