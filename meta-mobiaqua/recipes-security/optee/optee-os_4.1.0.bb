require optee-os.inc

SRCREV = "18b424c23aa5a798dfe2e4d20b4bde3919dc4e99"
