SRC_URI_remove = "file://0025-handle-sysroot-support-for-nativesdk-gcc.patch"
