SRC_URI:remove = "file://0024-handle-sysroot-support-for-nativesdk-gcc.patch"
