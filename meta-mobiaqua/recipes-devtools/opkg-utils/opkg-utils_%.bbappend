PYTHONRDEPS = ""

PACKAGECONFIG_remove = "python"
