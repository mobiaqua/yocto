UBOOT_MACHINE = "h3600_config"

require u-boot-pda_2016.05.inc
