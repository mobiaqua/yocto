PACKAGECONFIG:remove = "capabilities"
