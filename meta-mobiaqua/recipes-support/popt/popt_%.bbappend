EXTRA_OECONF:append:class-native = " am_cv_func_iconv=no --enable-shared=no"
EXTRA_OECONF:append:class-nativesdk = " am_cv_func_iconv=no --enable-shared=no"
