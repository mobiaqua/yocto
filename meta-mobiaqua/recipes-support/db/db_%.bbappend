EXTRA_OECONF_append_class-native = " --with-mutex=x86_64/gcc-assembly --enable-shared=no"
EXTRA_OECONF_append_class-nativesdk = " --with-mutex=x86_64/gcc-assembly --enable-shared=no"

