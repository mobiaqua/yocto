require scummvm.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG:prepend = "scummvm-${PV}:"

SRC_URI[sha256sum] = "a9d97b1a3a616abf27343e068cded67b486e4ded8f842c88b7e2957c33c1d48b"
