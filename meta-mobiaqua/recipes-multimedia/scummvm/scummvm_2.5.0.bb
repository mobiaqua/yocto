require scummvm.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG_prepend = "scummvm-${PV}:"

SRC_URI[sha256sum] = "05cce5ffa1f4b9ea4fc932fd65c42bf820bc5debd592a094ab1b809876a45bb5"
