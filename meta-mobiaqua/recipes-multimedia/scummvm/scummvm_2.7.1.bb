require scummvm.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG:prepend = "scummvm-${PV}:"

SRC_URI[sha256sum] = "dd303fc56805a4bc7c69990add566e149a0c3002f5c0e87df876c58e6b8df8cc"
