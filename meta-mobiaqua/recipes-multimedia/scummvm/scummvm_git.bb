require scummvm.inc

SRCREV = "29ab18020f4297e75f36b7dbfc6f89b42926e269"

SRC_URI = "git://github.com/scummvm/scummvm.git;protocol=https;branch=master"

S = "${WORKDIR}/git"
