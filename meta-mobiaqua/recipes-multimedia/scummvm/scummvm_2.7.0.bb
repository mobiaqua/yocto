require scummvm.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG:prepend = "scummvm-${PV}:"

SRC_URI[sha256sum] = "8003135c1c8999f9b79dc1d6a4f48ff79bb85ae800c72d94f3c7dd604db1c9c5"
