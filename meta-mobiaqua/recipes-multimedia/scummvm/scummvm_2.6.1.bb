require scummvm.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG:prepend = "scummvm-${PV}:"

SRC_URI[sha256sum] = "2e9451ea62f84596f6d87a4c384015b7202493a9f78256388c15a343d88b34cf"
