require scummvm.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG:prepend = "scummvm-${PV}:"

SRC_URI[sha256sum] = "d4eaf02e592a1b100d0d59ecf248541e8219252769777efeea182ca7dac4c519"
