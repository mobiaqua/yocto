PACKAGECONFIG_remove = "pulseaudio x11"
PACKAGECONFIG = "gles2 kmsdrm"
