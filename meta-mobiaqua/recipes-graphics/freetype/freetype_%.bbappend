PACKAGECONFIG:remove = "pixmap"
