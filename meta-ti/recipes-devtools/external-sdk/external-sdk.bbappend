DEPENDS:append:panda = " gdb-cross-arm libdce libdrm libmmrpc"
DEPENDS:append:beagle = " gdb-cross-arm libdce libdrm libmmrpc"
DEPENDS:append:beagle64 = " gdb-cross-aarch64 libdrm"
