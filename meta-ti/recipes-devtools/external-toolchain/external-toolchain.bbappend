DEPENDS:append:panda = "gdb-cross-arm"
DEPENDS:append:beagle = "gdb-cross-arm"
DEPENDS:append:beagle64 = "gdb-cross-aarch64"
