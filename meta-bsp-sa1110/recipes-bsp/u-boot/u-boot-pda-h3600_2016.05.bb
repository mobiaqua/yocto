UBOOT_MACHINE = "h3600_config"

require recipes-bsp/u-boot/u-boot-pda_2016.05.inc
