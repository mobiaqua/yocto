mobiaqua_rootfs_clean_boot_dir() {
	rm -f ${IMAGE_ROOTFS}/boot/*
}
