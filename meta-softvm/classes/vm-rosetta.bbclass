mobiaqua_rootfs_vm_rosetta() {
	mkdir -p ${IMAGE_ROOTFS}/rosetta
}
